File: kicad-pcbs/adxi/lpf-80m-smt.kicad_sch (KiCad schematic)
At the start: 7 parts

Commit message: More bands
Parts:
- renumbered C42 to C54, C43 to C55, L9 to L13
